VERSION ""

NS_ :

BS_:

BU_: edc viufl


BA_DEF_ BO_ "GenMsgCycleTime" INT 0 65535;
BA_DEF_ BO_ "GenMsgSendType" ENUM "Cyclic","Event","NotUsed";
